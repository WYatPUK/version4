# Keil uVision project central.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: central +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 central_main.c GeneralAnswer0526.h Communication_Profile0601.h GeneralAnswer0601.h Communication_Send_Central0601.h Communication_Receive_Central0601.h
