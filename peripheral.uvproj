# Keil uVision project peripheral.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: UUID1113 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Communication_Profile0601.h GeneralAnswer0601.h peripheral_main.c Communication_Receive_Central0601.h Communication_Send_Central0601.h link.h Find_Struct.h
